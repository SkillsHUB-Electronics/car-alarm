#include "Display.h"
#include <stdio.h>
#include <string.h>
#include <new>
#include "Settings.h"
#include "config.h"

Display::Display() : lcd_(LCD_ADDR, 16, 2) {}

void Display::begin() { apply(); }

// The LCD object keeps its I2C address in a private field, so it is rebuilt in place when the address changes.
void Display::apply() {
#if !INC_LCD
  active_ = false;  // no LCD in this build: nothing is ever sent on the I2C bus for it
  return;
#endif
  if (active_) {
    lcd_.clear();
    lcd_.noBacklight();
  }
  new (&lcd_) LiquidCrystal_I2C(hw.lcdAddr, 16, 2);
  last_[0][0] = last_[1][0] = '';
  active_ = hw.lcdOn != 0;
  lastDraw_ = 0;
  if (!active_) return;
  lcd_.init();
  if (hw.backlight) lcd_.backlight(); else lcd_.noBacklight();
}

// Writes a 16-char padded line, skipping the I2C traffic when nothing changed.
void Display::print(uint8_t row, const char *text) {
  if (!active_) return;
  char line[17];
  snprintf(line, sizeof(line), "%-16s", text);
  if (strcmp(line, last_[row]) == 0) return;
  strcpy(last_[row], line);
  lcd_.setCursor(0, row);
  lcd_.print(line);
}

void Display::showBoot(const char *line1, const char *line2) {
  print(0, line1);
  print(1, line2);
}

void Display::update(Status status, int16_t cm, bool motionOk, unsigned long now) {
  if (now - lastDraw_ < LCD_PERIOD_MS) return;
  lastDraw_ = now;

  const char *title = "";
  switch (status) {
    case Status::NORMAL: title = "SAFE"; break;
    case Status::WARN: title = "CLOSE DISTANCE"; break;
    case Status::DANGER: title = "DANGER: CLOSE!"; break;
    case Status::SHOCK: title = "IMPACT!"; break;
    case Status::BRAKE: title = "HARD BRAKING!"; break;
  }

  char dist[17];
  if (cm >= 0) {
    snprintf(dist, sizeof(dist), "Dist:%4dcm %s", (int)cm, motionOk ? "" : "ERR");
  } else {
    snprintf(dist, sizeof(dist), "Dist: --    %s", motionOk ? "" : "ERR");
  }
  print(0, title);
  print(1, dist);
}
